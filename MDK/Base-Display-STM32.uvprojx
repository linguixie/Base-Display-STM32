# Keil uVision project Base-Display-STM32.uvprojx, settings and files
target Base-Display-STM32 (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Base-Display-STM32 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F030, USE_STDPERIPH_DRIVER
  c include: ..\Lib\STM32F0xx_StdPeriph_Lib_V1.3.1\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Lib\STM32F0xx_StdPeriph_Lib_V1.3.1\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\Lib\STM32F0xx_StdPeriph_Lib_V1.3.1\Libraries\CMSIS\Include;..\Lib;..\HAL_Driver\SysTick;..\HAL_Driver\GPIO;..\HAL_Driver\Buzzer;..\HAL_Driver\Led;..\HAL_Driver\Key;..\HAL_Driver\Lcd;..\HAL_Driver\Infrared;..\HAL_Driver\EEPROM;..\HAL_Driver\Watchdog;..\Config;..\Platform\UI;..\Platform\SoftTimer;..\Platform\Valve;..\Platform\Math;..\Application\Display;..\Application\Output;..\Application\Main;..\Application\Communication;..\Application\Input;..\Includes
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../Application/Main/: Main.c
    ../Application/Display/: Display.c
    ../Application/Communication/: Communication.c
    ../Application/Input/: Input.c
    ../Application/Output/: Output.c
  group HAL_Driver
    ../HAL_Driver/LED/: Led.c
    ../HAL_Driver/SysTick/: SysTick.c
    ../HAL_Driver/GPIO/: GPIO.c
    ../HAL_Driver/Buzzer/: Buzzer.c
    ../HAL_Driver/Key/: Key.c
    ../HAL_Driver/Infrared/: Infrared.c
    ../HAL_Driver/EEPROM/: EEPROM.c
    ../HAL_Driver/Watchdog/: Watchdog.c
    ../HAL_Driver/Lcd/: Lcd.c
  group Platform
    ../Platform/UI/: UI.c
    ../Platform/SoftTimer/: SoftTimer.c
    ../Platform/Valve/: Valve.c
    ../Platform/Math/: Math.c
  group Lib
    ../Lib/STM32F0xx_StdPeriph_Lib_V1.3.1/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
    ../Lib/: system_stm32f0xx.c stm32f0xx_it.c startup_stm32f030.s
